# Keil uVision project Unicorn-V1.0.uvprojx, settings and files
target Test (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Unicorn-V1.0 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F103xx
  c include: .\CMSIS;.\my code;.\my image;.\Objects;.\StdPeriph_Driver;.\User;.\说明;.\StdPeriph_Driver\src;.\StdPeriph_Driver\inc;.\my code\12864;.\my code\ADC;.\my code\ADXL362;.\my code\Agreement\FreeModbus\Executable;.\my code\AT24C02;.\my code\Beep;.\my code\delay;.\my code\Usart;.\my code\Unicorn drive;.\my code\ESP8266;.\my code\I2C;.\my code\key;.\my code\LED;.\my code\SHT20;.\my code\SPI;.\my code\STMFLASH;.\my code\TIMER;.\my code\Agreement\FreeModbus\port;.\my code\Agreement\FreeModbus\modbus;.\my code\Agreement\FreeModbus\modbus\include;.\my code\system\System task;.\my code\system\FreeRTOS-8\include;.\my code\system\FreeRTOS-8\portable\Keil\ARM_CM3;.\my code\Agreement\FreeModbus\modbus\include;.\my code\Agreement\FreeModbus\modbus\functions;.\my code\Agreement\FreeModbus\modbus\ascii;.\my code\Agreement\FreeModbus\modbus\rtu;.\my code\Agreement\FreeModbus\modbus\tcp
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FreeModbus
    ./my code/Agreement/FreeModbus/Executable/: Executable.C
    ./my code/Agreement/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c mbcrc.h mbrtu.h
    ./my code/Agreement/FreeModbus/modbus/: mb.c
    ./my code/Agreement/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./my code/Agreement/FreeModbus/modbus/ascii/: mbascii.c
    ./my code/Agreement/FreeModbus/modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
    ./my code/Agreement/FreeModbus/modbus/tcp/: mbtcp.h
    ./my code/Agreement/FreeModbus/port/: port.h portevent.c portserial.c porttimer.c
  group FreeRTOS_Ports
    ./my code/system/System task/: Systemtask.c
    ./my code/system/FreeRTOS-8/portable/MemMang/: heap_4.c
    ./my code/system/FreeRTOS-8/portable/RVDS/ARM_CM3/: port.c portmacro.h
  group FreeRTOS_Source
    ./my code/system/FreeRTOS-8/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Mycode
    ./my code/12864/: OLED.C
    ./my code/ADC/: ADC.C
    ./my code/ADXL362/: ADXL362.c
    ./my code/AT24C02/: at24c02.c
    ./my code/Beep/: Beep.C
    ./my code/ESP8266/: esp8266.c
    ./my code/I2C/: i2c.c
    ./my code/key/: key.c
    ./my code/LED/: led.c
    ./my code/SHT20/: sht20.c
    ./my code/SPI/: spi.c
    ./my code/STMFLASH/: stmflash.c
    ./my code/Unicorn drive/: Unicorn_drive.c
    ./my code/Usart/: usart.c
    ./my code/delay/: delay.c
  group StdPeriph_Driver
    ./StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StartUp
    ./StartUp/: startup_stm32f10x_hd.s
  group User
    ./User/: FreeRTOSConfig.h includes.h main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group 说明
    ./说明/: 说明.txt
